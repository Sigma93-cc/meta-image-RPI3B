PACKAGECONFIG:append = " linuxfb evdev no-opengl"
PACKAGECONFIG:remove = "gbm tests examples"