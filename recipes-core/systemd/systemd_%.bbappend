PACKAGECONFIG:remove = "vconsole"