FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-rpi-SigmaOS-A-B-boot-env-and-writeable-list.patch \
    file://u-boot-ab.cfg \
"

